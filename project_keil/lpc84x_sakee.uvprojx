# Keil uVision project lpc84x_sakee.uvprojx, settings and files
target Debug In Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC845M301JHI48 NXP
  pack: Keil.LPC800_DFP.1.5.0
  cpu: IRAM(0x10000000,0x00004000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpc84x_sakee
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\csp_lpc84x;..\bsp_lpc84x_sakee;..\application\fatfs\fatfs_0.11a\src;..\application
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group application
    ../application/: keil_startup_lpc84x.s main.c driver_all_board.c driver_spi_oled.c driver_i2c_se95.c driver_dac_buzzer.c driver_capt_button.c driver_int_ec11.c driver_spi_sdcard.c driver_i2c_eeprom.c driver_adc_conti.c
  group csp
    ../csp_lpc84x/: acmp_84x.c adc_84x.c chip_84x.c clock_84x.c crc_84x.c dma_84x.c gpio_84x.c i2c_84x.c i2c_common_84x.c i2cm_84x.c i2cs_84x.c iocon_84x.c pinint_84x.c pmu_84x.c ring_buffer.c sct_84x.c spi_84x.c swm_84x.c syscon_84x.c sysinit_84x.c uart_84x.c wkt_84x.c wwdt_84x.c
  group bsp
    ../bsp_lpc84x_sakee/: board.c board_api_stubs_84x.c board_sysinit.c crp.c mtb.c sysinit.c
  group fatfs
    ../application/fatfs/fatfs_0.11a/src/: diskio.c ff.c
